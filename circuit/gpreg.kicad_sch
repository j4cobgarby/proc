File: circuit/gpreg.kicad_sch (KiCad schematic)
At the start: 35 parts

Commit message: update
Parts:
- gave numbers to parts that had none: 23
